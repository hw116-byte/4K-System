# Repository hw116-byte/4K-System (continued)

## KiCad design boards/1_HDMI_Extension_Board_V42/project/HDMI_Extension_Board_V42.kicad_pcb

Schematic: HDMI_Extension_Board_V42.kicad_sch, HDMI Extension Board - XEM8310 and USB-C JTAG

Parts:
C5: EEE-FK1E221GP; BRK_C5; VOLTAGE 25V; PARTNUMBER 001532; JLCPCB C401715
C6: CL05B104KB54PNC; BRK_C6; TOLERANCE (%) 10; VOLTAGE 50V; MANUFACTURER_PN CL05B104KB54PNC; JLCPCB C307331
C7: CL05B104KO5NNNC; BRK8310_C7; PARTNUMBER 000070; JLCPCB C1525
C8: CL05B104KO5NNNC; BRK8310_C8; PARTNUMBER 000070; JLCPCB C1525
C9: CL05B104KO5NNNC; BRK8310_C9; PARTNUMBER 000070; JLCPCB C1525
C10: CL05B104KO5NNNC; BRK8310_C10; PARTNUMBER 000070; JLCPCB C1525
C11: CL05B104KO5NNNC; BRK8310_C11; PARTNUMBER 000070; JLCPCB C1525
C12: CL05B104KO5NNNC; BRK8310_C12; PARTNUMBER 000070; JLCPCB C1525
C13: CL05B224KO5NNNC; BRK8310_C13; MANUFACTURER_PN CL05B224KO5NNNC; JLCPCB C16772
C14: CL05B224KO5NNNC; BRK8310_C14; MANUFACTURER_PN CL05B224KO5NNNC; JLCPCB C16772
C15: CL05B224KO5NNNC; BRK8310_C15; MANUFACTURER_PN CL05B224KO5NNNC; JLCPCB C16772
C16: CL05B224KO5NNNC; BRK8310_C16; MANUFACTURER_PN CL05B224KO5NNNC; JLCPCB C16772
C17: CL05B224KO5NNNC; BRK8310_C17; MANUFACTURER_PN CL05B224KO5NNNC; JLCPCB C16772
C18: CL05B224KO5NNNC; BRK8310_C18; MANUFACTURER_PN CL05B224KO5NNNC; JLCPCB C16772
C19: CL05B224KO5NNNC; BRK8310_C19; MANUFACTURER_PN CL05B224KO5NNNC; JLCPCB C16772
C20: CL05B224KO5NNNC; BRK8310_C20; MANUFACTURER_PN CL05B224KO5NNNC; JLCPCB C16772
C27: CL05B104KO5NNNC; BRK8310_C27; PARTNUMBER 000070; JLCPCB C1525
C28: CL05B104KO5NNNC; BRK8310_C28; PARTNUMBER 000070; JLCPCB C1525
C31: CL05B104KO5NNNC; BRK8310_C31; PARTNUMBER 000070; JLCPCB C1525
C32: CL05B104KO5NNNC; BRK8310_C32; PARTNUMBER 000070; JLCPCB C1525
C500: 4.7u; C500; Voltage 10V; MPN C1005X5R1A475KTJ00E; JLCPCB C342983
C501: 100n; C501; Voltage 16V; MPN CL05B104KO5NNNC; JLCPCB C1525
C502: 100n; C502; MPN CL05B104KO5NNNC; JLCPCB C1525
C503: 18p; C503; MPN C0402C180J5GACTU; JLCPCB C22442494
C504: 18p; C504; MPN C0402C180J5GACTU; JLCPCB C22442494
C505: 100n; C505; MPN CL05B104KO5NNNC; JLCPCB C1525
C506: 100n; C506; Voltage 16V; Tolerance 10%; MPN CL05B104KO5NNNC; JLCPCB C1525
C507: 4.7u; C507; Voltage 6.3V; Tolerance 20%; MPN JMK105BBJ475MV-F; JLCPCB C87147
C508: 100n; C508; Voltage 16V; Tolerance 10%; MPN CL05B104KO5NNNC; JLCPCB C1525
C509: 100n; C509; Voltage 16V; Tolerance 10%; MPN CL05B104KO5NNNC; JLCPCB C1525
C510: 100n; C510; Voltage 16V; Tolerance 10%; MPN CL05B104KO5NNNC; JLCPCB C1525
C511: 100n; C511; Voltage 16V; Tolerance 10%; MPN CL05B104KO5NNNC; JLCPCB C1525
C512: 4.7u; C512; Voltage 6.3V; Tolerance 20%; MPN JMK105BBJ475MV-F; JLCPCB C87147
C513: 4.7u; C513; Voltage 6.3V; Tolerance 20%; MPN JMK105BBJ475MV-F; JLCPCB C87147
C514: 100n; C514; Voltage 16V; Tolerance 10%; MPN CL05B104KO5NNNC; JLCPCB C1525
C515: 4.7u; C515; Voltage 6.3V; Tolerance 20%; MPN JMK105BBJ475MV-F; JLCPCB C87147
C516: 100n; C516; Voltage 16V; Tolerance 10%; MPN CL05B104KO5NNNC; JLCPCB C1525
C517: 100n; C517; Voltage 16V; Tolerance 10%; MPN CL05B104KO5NNNC; JLCPCB C1525
C518: 100n; C518; Voltage 16V; Tolerance 10%; MPN CL05B104KO5NNNC; JLCPCB C1525
C519: 10n; C519; Voltage 16V; Tolerance 10%; MPN C0402C103K4RACTU; JLCPCB C2649513
C601, C603: 2.2u; C_0603_1608Metric; JLCPCB C100082
C604, C605, C606, C609, C610, C611, C612, C613, C614, C615, C616, C617, C618: 100n; C_0603_1608Metric; JLCPCB C14663
C608: 1n; C_0603_1608Metric; JLCPCB C8808
C700, C701, C702, C703: 10uF; C_1210_3225Metric; Manufacturer_PN GRM32ER71H106KA12L; JLCPCB C77102
C704, C705, C706, C707: 47uF; C_1210_3225Metric; Manufacturer_PN GRM32ER61C476KE15L; JLCPCB C77101
C708: 22pF; C_0603_1608Metric; Manufacturer_PN TCC0603COG220J500CT; JLCPCB C376775
C711, C712, C713, C714, C715, C716, C717, C718: 100nF; C_0603_1608Metric; Manufacturer_PN CC0603KRX7R9BB104; JLCPCB C14663
C721, C722, C723, C724, C725, C726, C727, C728: 1uF; C_0603_1608Metric; Manufacturer_PN CL10A105KB8NNNC; JLCPCB C15849
C745, C746, C747, C748, C749, C750, C751, C752, C753, C754, C755, C756, C757, C758, C759, C760: CL05B104KO5NNNC; C_0402_1005Metric; MANUFACTURER_PN CL05B104KO5NNNC; JLCPCB C1525
D500: USBLC6-2SC6; D500; Manufacturer_PN USBLC6-2SC6; JLCPCB C7519
D701, D702, D703, D704, D705, D706, D707, D708: RED; LED_0603_1608Metric; Manufacturer_PN LTST-C190KRKT; JLCPCB C94869
FB500: 600R; FB500; MPN BLM18AG601SN1D; JLCPCB C19330
FB501: 600R; FB501; MPN BLM18AG601SN1D; JLCPCB C19330
FB502: 600R; FB502; MPN BLM18AG601SN1D; JLCPCB C19330
FB503: 220R @100MHz; FB503; MANUFACTURER_PN MPZ2012S221AT000; JLCPCB C76818
J4: PJ-063AH; BarrelJack_CUI_PJ-063AH_Horizontal; MANUFACTURER_PN PJ-063AH; JLCPCB C22434582
J6: PCIe x8 Card-Edge Connector; BRK8310_J6
J500: USB4110-GF-A; J500; MANUFACTURER_PN USB4110-GF-A; JLCPCB C5143397
J610, J611, J612, J613, J614, J615, J616, J617: 467651001; HDMI_Micro-D_Molex_46765-1xxx; JLCPCB C563878
J900, J901: YXY-PZ2.0-2X14PIN-DIP; PinHeader_2x14_P2.00mm_V41; MPN YXY-PZ2.0-2X14PIN-DIP; LCSC C56596886
J902: YXY-PZ2.0-1X14PIN-DIP; PinHeader_1x14_P2.00mm_V41; MPN YXY-PZ2.0-1X14PIN-DIP; LCSC C56596719
J910: YXY-PZ2.0-2X15PIN-DIP; PinHeader_2x15_P2.00mm_V41; MPN YXY-PZ2.0-2X15PIN-DIP; LCSC C56596887
J911: YXY-PZ2.0-1X15PIN-DIP; PinHeader_1x15_P2.00mm_V41; MPN YXY-PZ2.0-1X15PIN-DIP; LCSC C56596720
J920, J921, J922, J923, J924, J925, J926, J927, J928: PZ254V-11-01P; PinHeader_1x01_P2.54mm_Pad2.54_D1.1_V41; MPN PZ254V-11-01P; LCSC C492400
J930: 22-05-3031; Molex_KK-254_22-05-3031_1x03_P2.54mm_Horizontal; MPN 22-05-3031; LCSC C505040
MC1: BTE-040-01-F-D-A; BRK_MC1; PARTNUMBER 000059; JLCPCB C2914307
MC2: BTE-040-01-F-D-A; BRK_MC2; PARTNUMBER 000059; JLCPCB C2914307
MC3: QTH-040-01-F-D-DP-A; BRK_MC3; PARTNUMBER 002313; JLCPCB C7330812
Q1: SI1922EDH-T1-GE3; BRK8310_Q1; PARTNUMBER 002018; JLCPCB C141538
R2: CRCW06030000Z0EA; BRK8310_R2; MANUFACTURER_PN CRCW06030000Z0EA; JLCPCB C844915
R7: CRCW06030000Z0EA; BRK8310_R7; MANUFACTURER_PN CRCW06030000Z0EA; JLCPCB C844915
R9: CRCW06030000Z0EA; BRK8310_R9; MANUFACTURER_PN CRCW06030000Z0EA; JLCPCB C844915
R10: CRCW06030000Z0EA; BRK8310_R10; MANUFACTURER_PN CRCW06030000Z0EA; JLCPCB C844915
R11: CRCW06030000Z0EA; BRK8310_R11; MANUFACTURER_PN CRCW06030000Z0EA; JLCPCB C844915
R13: CRCW0402200KFKED; BRK8310_R13; PARTNUMBER 000964; JLCPCB C482093
R14: CRCW04024K75FKED; BRK8310_R14; PARTNUMBER 001008; JLCPCB C844510
R15: CRCW04024K75FKED; BRK8310_R15; PARTNUMBER 001008; JLCPCB C844510
R18: CRCW0402100KFKED; BRK8310_R18; TOLERANCE (%) 1; PARTNUMBER 001070; JLCPCB C481918
R23: CRCW0402200KFKED; BRK8310_R23; PARTNUMBER 000964; JLCPCB C482093
R24: CRCW0402100KFKED; BRK8310_R24; TOLERANCE (%) 1; PARTNUMBER 001070; JLCPCB C481918
R25: CRCW0402100KFKED; BRK8310_R25; TOLERANCE (%) 1; PARTNUMBER 001070; JLCPCB C481918
R28: CRCW04020000Z0ED; BRK8310_R28; PARTNUMBER 000755; JLCPCB C190119
R30: CRCW04024K75FKED; BRK8310_R30; PARTNUMBER 001008; JLCPCB C844510
R31: CRCW04024K75FKED; BRK8310_R31; PARTNUMBER 001008; JLCPCB C844510
R32: CRCW0402100KFKED; BRK8310_R32; TOLERANCE (%) 1; PARTNUMBER 001070; JLCPCB C481918
R33: CRCW0402100KFKED; BRK8310_R33; TOLERANCE (%) 1; PARTNUMBER 001070; JLCPCB C481918
R500: 5.1k 1%; R500; MPN CRCW04025K10FKEDC; JLCPCB C2076825
R501: 5.1k 1%; R501; MPN CRCW04025K10FKEDC; JLCPCB C2076825
R502: 100k; R502; Tolerance 1%; MPN CRCW0402100KFKED; JLCPCB C481918
R503: 100k; R503; Tolerance 1%; MPN CRCW0402100KFKED; JLCPCB C481918
R504: 2k; R504; Tolerance 1%; MPN CRCW04022K00FKED; JLCPCB C482125
R505: 10k; R505; Tolerance 1%; MPN CRCW040210K0FKED; JLCPCB C71617
R506: 10k; R506; Tolerance 1%; MPN CRCW040210K0FKED; JLCPCB C71617
R507: 12k 1%; R507; Tolerance 1%; MPN CRCW040212K0FKED; JLCPCB C481938
R509: 10k; R509; Manufacturer_PN CRCW040210K0FKED; JLCPCB C71617
R600: 3.3k; R_0603_1608Metric; JLCPCB C22978
R601, R602, R603: 22R; R_0603_1608Metric; JLCPCB C23345
R605: 301k; R_0603_1608Metric; JLCPCB C23026
R606, R608, R616: 100k; R_0603_1608Metric; JLCPCB C25803
R607: 402k; R_0603_1608Metric; JLCPCB C23048
R613: 68k; R_0603_1608Metric; JLCPCB C23231
R614: 4.7k; R_0603_1608Metric; JLCPCB C23162
R615: 12k; R_0603_1608Metric; JLCPCB C22790
R620, R621, R622, R623, R624, R625, R626, R627, R628: 10k; R_0603_1608Metric; JLCPCB C25804
R629: 1k; R_0603_1608Metric; JLCPCB C21190
R640, R641, R642, R643, R644, R645, R646, R647, R648, R649, R650, R651, R652, R653, R654, R655, R656, R657, R658, R659, R660, R661, R662, R663, R664, R665, R666, R667, R668, R669, R670, R671: 100R; R_0603_1608Metric; JLCPCB C22775
R700: 40.2k; R_0603_1608Metric; Manufacturer_PN RC0603FR-0740K2L; JLCPCB C137723
R701, R703: 10k; R_0603_1608Metric; Manufacturer_PN RC0603FR-0710KL; JLCPCB C98220
R702: 13k; R_0603_1608Metric; Manufacturer_PN 0603WAF1302T5E; JLCPCB C22797
R711, R712, R713, R714, R715, R716, R717, R718: 37.4k; R_0603_1608Metric; Manufacturer_PN AC0603FR-0737K4L; JLCPCB C227846
R721, R722, R723, R724, R725, R726, R727, R728: 3.3k; R_0603_1608Metric; Manufacturer_PN 0603WAF3301T5E; JLCPCB C22978
SW600: SRBQ490100; ALPS_SRBQ490100_1P9T; JLCPCB C370985
SW601: JS202011JCQN; SW700; JLCPCB C221665
TP9: SMDAT_VIO; BRK8310_TP9
TP10: SMDAT_PCIE; BRK8310_TP10
TP11: SMCLK_PCIE; BRK8310_TP11
TP12: SMCLK_VIO; BRK8310_TP12
TP13: PERST_VIO; BRK8310_TP13
TP14: PERST_PCIE; BRK8310_TP14
TP15: WAKE_VIO; BRK8310_TP15
TP16: WAKE_PCIE; BRK8310_TP16
TP20: +12V_PCIE_C; BRK8310_TP20
TP21: FAULT; BRK8310_TP21
TP700, TP701, TP702, TP703, TP704, TP705, TP706, TP707, TP708, TP709: TestPoint; TestPoint_Pad_D1.5mm
TP710: 12V_IN; TestPoint_Pad_D1.5mm
TP711: 1V8_XEM; TestPoint_Pad_D1.5mm
TP712: 3V3_XEM; TestPoint_Pad_D1.5mm
TP713: 3V3_FTDI; TestPoint_Pad_D1.5mm
TP720, TP721, TP722, TP723, TP725, TP729, TP732, TP733, TP734, TP735, TP736, TP737, TP738, TP739: TestPoint; TestPoint_Pad_D1.0mm
TP724, TP727, TP728: TestPoint; TestPoint_Pad_D0.8mm
TP726, TP730, TP731: TestPoint; TestPoint_Pad_D0.6mm
U2: PCA9306DCUR; BRK8310_U2; PARTNUMBER 001474; JLCPCB C33196
U4: SN74AXC1T45DCK; BRK8310_U4; PARTNUMBER 002140; JLCPCB C2677392
U5: AP22653AW6-7; BRK8310_U5; PARTNUMBER 002224; JLCPCB C1511768
U6: PCA9306DCUR; BRK8310_U6; PARTNUMBER 001474; JLCPCB C33196
U501: FT232HQ-REEL; U501; MANUFACTURER_PN FT232HQ; JLCPCB C82158
U505: 93LC56BT-I/SN; SOIC-8_3.9x4.9mm_P1.27mm; MANUFACTURER_PN 93LC56BT-I/SN; JLCPCB C6164
U602: TXU0304PWR; TSSOP-14_4.4x5mm_P0.65mm; JLCPCB C4364118
U603: TPS3700DDCR; SOT-23-6; JLCPCB C33002
U605: TPS3808G30DBVR; SOT-23-6; JLCPCB C189211
U610, U611, U612, U613, U614, U615, U616, U617, U618: TS3A27518EPWR; TSSOP-24_4.4x7.8mm_P0.65mm; JLCPCB C443721
U700: TPSM63606RDLR; TI_TPSM63606_RDL0020A_EVM; Manufacturer_PN TPSM63606RDLR; JLCPCB C5219325
U701, U702, U703, U704, U705, U706, U707, U708: TPS2553DBVR; SOT-23-6; Manufacturer_PN TPS2553DBVR; JLCPCB C55266
U801, U802, U803, U804, U805, U806, U807, U808, U809, U810, U811, U812, U813, U814, U815, U816: TPD4E02B04DQAR; USON-10_2.5x1.0mm_P0.5mm; Manufacturer_PN TPD4E02B04DQAR; JLCPCB C106794
Y500: 7U12000E18UCG 12MHz; Y500; MPN 7U12000E18UCG; JLCPCB C524717

Connections:
+1.2V_DDR: J920.1, MC3.80 (+1.2V_DDR), R2.2
+1.8V: C603.1, C605.1, J922.1, MC1.2 (+1.8V), R629.2, TP711.1, U602.14 (VCCB_1V8)
+3.3V: C601.1, C606.1, C609.1, C610.1, C611.1, C612.1, C613.1, C614.1, C615.1, C616.1, C617.1, C618.1, J926.1, MC2.70 (+3.3V), R30.2, R31.2, R615.1, R620.1, R621.1, R622.1, R623.1, R624.1, R625.1, R626.1, R627.1, R628.1, SW601.5 (ENABLE_3V3), TP712.1, U603.5 (VDD), U605.5 (SENSE), U605.6 (VDD), U610.8 (VCC_3V3), U610.14 (IN2_HIGH), U610.24 (IN1_HIGH), U611.8 (VCC_3V3), U611.14 (IN2_HIGH), U611.24 (IN1_HIGH), U612.8 (VCC_3V3), U612.14 (IN2_HIGH), U612.24 (IN1_HIGH), U613.8 (VCC_3V3), U613.14 (IN2_HIGH), U613.24 (IN1_HIGH), U614.8 (VCC_3V3), U614.14 (IN2_HIGH), U614.24 (IN1_HIGH), U615.8 (VCC_3V3), U615.14 (IN2_HIGH), U615.24 (IN1_HIGH), U616.8 (VCC_3V3), U616.14 (IN2_HIGH), U616.24 (IN1_HIGH), U617.8 (VCC_3V3), U617.14 (IN2_HIGH), U617.24 (IN1_HIGH), U618.8 (VCC_3V3), U618.14 (IN2_HIGH), U618.24 (IN1_HIGH)
+3.3VAUX_PCIE: C31.2, R13.2, R23.2, U5.6 (OUT)
+3.3VAUX_PCIE_C: C32.2, J6.B10 (3.3Vaux), R18.2, U5.1 (IN)
+3.3V_PCIE_C: C12.2, J6.A9 (+3.3V), J6.A10 (+3.3V), J6.B8 (+3.3V), U4.6 (Vccb)
+VDCIN: C5.1, C6.2, C700.1, C701.1, C702.1, C703.1, J4.1, J924.1, J930.2 (+12V), MC2.1 (+VDCIN), MC2.2 (+VDCIN), MC2.3 (+VDCIN), MC2.4 (+VDCIN), TP710.1, U700.1 (VIN1), U700.14 (EN/SYNC), U700.16 (VIN2)
/+12V_PCIE_C: J6.A2 (+12V), J6.A3 (+12V), J6.B1 (+12V), J6.B2 (+12V), J6.B3 (+12V), TP20.1
/FTDI3V3_PHY: C515.1, C516.1, FB501.2, U501.3 (VPHY)
/FTDI3V3_PLL: C513.1, C514.1, FB500.2, U501.8 (VPLL)
/FTDI5V_FILTERED: C500.1, C501.1, FB502.2, U501.40 (VREGIN)
/FTDI_EECLK: R503.2, U501.44 (EECLK), U505.2 (CLK)
/FTDI_EECS: R502.1, U501.45 (EECS), U505.1 (CS)
/FTDI_EEDATA: R504.1, U501.43 (EEDATA), U505.3 (DI)
/PCIE_PERST_B_3V3: J6.A11 (PERST#), TP14.1, U4.4 (B)
/PCIE_PERST_B_VIO: R7.1, TP13.1, U4.3 (A)
/PCIE_PRSNT1_B: J6.A1 (PRSNT1#), R28.2
/PCIE_REFCLKN_C: C8.1, J6.A14 (REFCLK-)
/PCIE_REFCLKP_C: C7.1, J6.A13 (REFCLK+)
/PCIE_RX0N_C: C14.1, J6.A17 (PERn0)
/PCIE_RX0P_C: C13.1, J6.A16 (PERp0)
/PCIE_RX1N_C: C16.1, J6.A22 (PERn1)
/PCIE_RX1P_C: C15.1, J6.A21 (PERp1)
/PCIE_RX2N_C: C18.1, J6.A26 (PERn2)
/PCIE_RX2P_C: C17.1, J6.A25 (PERp2)
/PCIE_RX3N_C: C20.1, J6.A30 (PERn3)
/PCIE_RX3P_C: C19.1, J6.A29 (PERp3)
/PCIE_SMCLK_3V3: J6.B5 (SMCLK), TP11.1, U2.5 (SDA2)
/PCIE_SMCLK_VIO: R11.1, R14.1, TP12.1, U2.4 (SDA1)
/PCIE_SMDAT_3V3: J6.B6 (SMDAT), TP10.1, U2.6 (SCL2)
/PCIE_SMDAT_VIO: R10.1, R15.1, TP9.1, U2.3 (SCL1)
/PCIE_WAKE_B_3V3: J6.B11 (WAKE#), TP16.1, U6.6 (SCL2)
/PCIE_WAKE_B_VIO: R9.1, R25.1, TP15.1, U6.3 (SCL1)
/VIO_PG: Q1.3 (D2), R31.1, R32.2, TP738.1, U5.3 (EN)
B64_L1N: J614.8 (CLK_N), MC1.12 (B64_L1N), U813.4 (IO3), U813.7 (IO3_FT)
B64_L1P: J614.6 (CLK_P), MC1.10 (B64_L1P), U813.5 (IO4), U813.6 (IO4_FT)
B64_L2N: J615.11 (CMD_N), MC1.16 (B64_L2N), U806.5 (IO4), U806.6 (IO4_FT)
B64_L2P: J615.9 (CMD_P), MC1.14 (B64_L2P), U806.4 (IO3), U806.7 (IO3_FT)
B64_L3N: J611.11 (CMD_N), MC1.15 (B64_L3N), U802.5 (IO4), U802.6 (IO4_FT)
B64_L3P: J611.9 (CMD_P), MC1.13 (B64_L3P), U802.4 (IO3), U802.7 (IO3_FT)
B64_L4N: J614.11 (CMD_N), MC1.8 (B64_L4N), U805.5 (IO4), U805.6 (IO4_FT)
B64_L4P: J614.9 (CMD_P), MC1.6 (B64_L4P), U805.4 (IO3), U805.7 (IO3_FT)
B64_L5N: J610.11 (CMD_N), MC1.7 (B64_L5N), U801.5 (IO4), U801.6 (IO4_FT)
B64_L5P: J610.9 (CMD_P), MC1.5 (B64_L5P), U801.4 (IO3), U801.7 (IO3_FT)
B64_L6N: J610.8 (CLK_N), MC1.11 (B64_L6N), U809.4 (IO3), U809.7 (IO3_FT)
B64_L6P: J610.6 (CLK_P), MC1.9 (B64_L6P), U809.5 (IO4), U809.6 (IO4_FT)
B64_L7N: J612.11 (CMD_N), MC1.23 (B64_L7N), U803.5 (IO4), U803.6 (IO4_FT)
B64_L7P: J612.9 (CMD_P), MC1.21 (B64_L7P), U803.4 (IO3), U803.7 (IO3_FT)
B64_L8N: J615.8 (CLK_N), MC1.20 (B64_L8N), U814.4 (IO3), U814.7 (IO3_FT)
B64_L8P: J615.6 (CLK_P), MC1.18 (B64_L8P), U814.5 (IO4), U814.6 (IO4_FT)
B64_L9N: J616.11 (CMD_N), MC1.24 (B64_L9N), U807.5 (IO4), U807.6 (IO4_FT)
B64_L9P: J616.9 (CMD_P), MC1.22 (B64_L9P), U807.4 (IO3), U807.7 (IO3_FT)
B64_L10N: J616.8 (CLK_N), MC1.28 (B64_L10N), U815.4 (IO3), U815.7 (IO3_FT)
B64_L10P: J616.6 (CLK_P), MC1.26 (B64_L10P), U815.5 (IO4), U815.6 (IO4_FT)
B64_L11N_GC: J613.8 (CLK_N), MC1.39 (B64_L11N_GC), U812.4 (IO3), U812.7 (IO3_FT)
B64_L11P_GC: J613.6 (CLK_P), MC1.37 (B64_L11P_GC), U812.5 (IO4), U812.6 (IO4_FT)
B64_L12N_GC: J910.4, MC1.43 (B64_L12N_GC)
B64_L12P_GC: J910.1, MC1.41 (B64_L12P_GC)
B64_L13N_GC: J612.8 (CLK_N), MC1.27 (B64_L13N_GC), U811.4 (IO3), U811.7 (IO3_FT)
B64_L13P_GC: J612.6 (CLK_P), MC1.25 (B64_L13P_GC), U811.5 (IO4), U811.6 (IO4_FT)
B64_L14N_GC: J910.6, MC1.47 (B64_L14N_GC)
B64_L14P_GC: J910.3, MC1.45 (B64_L14P_GC)
B64_L15N: J613.11 (CMD_N), MC1.35 (B64_L15N), U804.5 (IO4), U804.6 (IO4_FT)
B64_L15P: J613.9 (CMD_P), MC1.33 (B64_L15P), U804.4 (IO3), U804.7 (IO3_FT)
B64_L16N: J612.14 (SYNC_N), MC1.51 (B64_L16N), U811.1 (IO1), U811.10 (IO1_FT)
B64_L16P: J612.12 (SYNC_P), MC1.49 (B64_L16P), U811.2 (IO2), U811.9 (IO2_FT)
B64_L17N: MC1.44 (B64_L17N), R11.2
B64_L17P: MC1.42 (B64_L17P), R10.2
B64_L18N: J615.14 (SYNC_N), MC1.56 (B64_L18N), U814.1 (IO1), U814.10 (IO1_FT)
B64_L18P: J615.12 (SYNC_P), MC1.54 (B64_L18P), U814.2 (IO2), U814.9 (IO2_FT)
B64_L19N: J611.8 (CLK_N), MC1.19 (B64_L19N), U810.4 (IO3), U810.7 (IO3_FT)
B64_L19P: J611.6 (CLK_P), MC1.17 (B64_L19P), U810.5 (IO4), U810.6 (IO4_FT)
B64_L20N: MC1.40 (B64_L20N), R9.2
B64_L20P: J910.7, MC1.38 (B64_L20P)
B64_L21N: J617.11 (CMD_N), MC1.36 (B64_L21N), U808.5 (IO4), U808.6 (IO4_FT)
B64_L21P: J617.9 (CMD_P), MC1.34 (B64_L21P), U808.4 (IO3), U808.7 (IO3_FT)
B64_L22N: J614.14 (SYNC_N), MC1.52 (B64_L22N), U813.1 (IO1), U813.10 (IO1_FT)
B64_L22P: J614.12 (SYNC_P), MC1.50 (B64_L22P), U813.2 (IO2), U813.9 (IO2_FT)
B64_L23N: J613.14 (SYNC_N), MC1.55 (B64_L23N), U812.1 (IO1), U812.10 (IO1_FT)
B64_L23P: J613.12 (SYNC_P), MC1.53 (B64_L23P), U812.2 (IO2), U812.9 (IO2_FT)
B64_L24N: J617.8 (CLK_N), MC1.48 (B64_L24N), U816.4 (IO3), U816.7 (IO3_FT)
B64_L24P: J617.6 (CLK_P), MC1.46 (B64_L24P), U816.5 (IO4), U816.6 (IO4_FT)
B64_T0U_N12: J910.5, MC1.32 (B64_T0U_N12)
B64_T1U_N12: J910.2, MC1.31 (B64_T1U_N12)
B64_T2U_N12: J910.20, MC1.57 (B64_T2U_N12)
B64_T3U_N12: J910.10, MC1.58 (B64_T3U_N12)
B67_T3U_N12: MC3.78 (B67_T3U_N12), R7.2
B84_L1N: J910.12, MC1.64 (B84_L1N)
B84_L1P: J910.9, MC1.62 (B84_L1P)
B84_L2N: J910.26, MC1.71 (B84_L2N)
B84_L2P: J910.23, MC1.69 (B84_L2P)
B84_L3N: J910.16, MC1.72 (B84_L3N)
B84_L3P: J910.13, MC1.70 (B84_L3P)
B84_L4N: J910.22, MC1.63 (B84_L4N)
B84_L4P: J910.19, MC1.61 (B84_L4P)
B84_L5N_HDGC: J910.18, MC1.76 (B84_L5N_HDGC)
B84_L5P_HDGC: J910.15, MC1.74 (B84_L5P_HDGC)
B84_L6N_HDGC: J910.24, MC1.67 (B84_L6N_HDGC)
B84_L6P_HDGC: J910.21, MC1.65 (B84_L6P_HDGC)
B84_L7N_HDGC: J901.3, MC2.62 (B84_L7N_HDGC)
B84_L7P_HDGC: J901.4, MC2.60 (B84_L7P_HDGC)
B84_L8N_HDGC: J910.28, MC1.75 (B84_L8N_HDGC)
B84_L8P_HDGC: J910.25, MC1.73 (B84_L8P_HDGC)
B84_L9N: J910.14, MC1.68 (B84_L9N)
B84_L9P: J910.11, MC1.66 (B84_L9P)
B84_L10N: J901.27, MC2.61 (B84_L10N)
B84_L10P: J901.26, MC2.59 (B84_L10P)
B84_L11N: J901.1, MC2.66 (B84_L11N)
B84_L11P: J901.2, MC2.64 (B84_L11P)
B84_L12N: J900.25, MC2.65 (B84_L12N)
B84_L12P: J900.23, MC2.63 (B84_L12P)
B86_L1N: J901.16, MC2.57 (B86_L1N)
B86_L1P: J901.17, MC2.55 (B86_L1P)
B86_L2N: J901.9, MC2.50 (B86_L2N)
B86_L2P: J901.10, MC2.48 (B86_L2P)
B86_L3N: J901.20, MC2.49 (B86_L3N)
B86_L3P: J901.21, MC2.47 (B86_L3P)
B86_L4N: J900.11, MC2.45 (B86_L4N)
B86_L4P: J900.13, MC2.43 (B86_L4P)
B86_L5N_HDGC: J901.5, MC2.58 (B86_L5N_HDGC)
B86_L5P_HDGC: J901.6, MC2.56 (B86_L5P_HDGC)
B86_L6N_HDGC: J901.7, MC2.54 (B86_L6N_HDGC)
B86_L6P_HDGC: J901.8, MC2.52 (B86_L6P_HDGC)
B86_L7N_HDGC: J901.13, MC2.42 (B86_L7N_HDGC)
B86_L7P_HDGC: J901.14, MC2.40 (B86_L7P_HDGC)
B86_L8N_HDGC: J900.15, MC2.41 (B86_L8N_HDGC)
B86_L8P_HDGC: J900.17, MC2.39 (B86_L8P_HDGC)
B86_L9N: J901.18, MC2.53 (B86_L9N)
B86_L9P: J901.19, MC2.51 (B86_L9P)
B86_L10N: J901.11, MC2.46 (B86_L10N)
B86_L10P: J901.12, MC2.44 (B86_L10P)
B86_L11N: J902.2, MC2.38 (B86_L11N)
B86_L11P: J902.1, MC2.36 (B86_L11P)
B86_L12N: J900.19, MC2.37 (B86_L12N)
B86_L12P: J900.21, MC2.35 (B86_L12P)
B87_L1N: J900.1, MC2.32 (B87_L1N)
B87_L1P: J900.3, MC2.30 (B87_L1P)
B87_L2N: J900.8, MC2.12 (B87_L2N)
B87_L2P: J900.10, MC2.10 (B87_L2P)
B87_L3N: J900.4, MC2.16 (B87_L3N)
B87_L3P: J900.6, MC2.14 (B87_L3P)
B87_L4N: J901.24, MC2.11 (B87_L4N)
B87_L4P: J901.25, MC2.9 (B87_L4P)
B87_L5N_HDGC: J900.12, MC2.31 (B87_L5N_HDGC)
B87_L5P_HDGC: J900.14, MC2.29 (B87_L5P_HDGC)
B87_L6N_HDGC: J900.24, MC2.19 (B87_L6N_HDGC)
B87_L6P_HDGC: J900.26, MC2.17 (B87_L6P_HDGC)
B87_L7N_HDGC: J900.16, MC2.27 (B87_L7N_HDGC)
B87_L7P_HDGC: J900.18, MC2.25 (B87_L7P_HDGC)
B87_L8N_HDGC: J900.9, MC2.24 (B87_L8N_HDGC)
B87_L8P_HDGC: J902.4, MC2.22 (B87_L8P_HDGC)
B87_L9N: J902.3, MC2.20 (B87_L9N)
B87_L9P: J900.2, MC2.18 (B87_L9P)
B87_L10N: J900.20, MC2.23 (B87_L10N)
B87_L10P: J900.22, MC2.21 (B87_L10P)
B87_L11N: J900.5, MC2.28 (B87_L11N)
B87_L11P: J900.7, MC2.26 (B87_L11P)
B87_L12N: J901.22, MC2.15 (B87_L12N)
B87_L12P: J901.23, MC2.13 (B87_L12P)
DGND: C5.2, C6.1, C9.1, C10.1, C11.1, C12.1, C27.1, C28.1, C31.1, C32.1, C500.2, C501.2, C502.2, C503.2, C504.2, C505.2, C506.1, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, C513.2, C514.2, C515.2, C516.2, C517.1, C518.1, C519.2, C601.2, C603.2, C604.2, C605.2, C606.2, C608.2, C609.2, C610.2, C611.2, C612.2, C613.2, C614.2, C615.2, C616.2, C617.2, C618.2, C700.2, C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, C707.2, C711.2, C712.2, C713.2, C714.2, C715.2, C716.2, C717.2, C718.2, C721.2, C722.2, C723.2, C724.2, C725.2, C726.2, C727.2, C728.2, D500.2 (GND), FB503.1, J4.2, J6.A4 (GND), J6.A12 (GND), J6.A15 (GND), J6.A18 (GND), J6.A20 (GND), J6.A23 (GND), J6.A24 (GND), J6.A27 (GND), J6.A28 (GND), J6.A31 (GND), J6.A34 (GND), J6.A37 (GND), J6.A38 (GND), J6.A41 (GND), J6.A42 (GND), J6.A45 (GND), J6.A46 (GND), J6.A49 (GND), J6.B4 (GND), J6.B7 (GND), J6.B13 (GND), J6.B16 (GND), J6.B18 (GND), J6.B21 (GND), J6.B22 (GND), J6.B25 (GND), J6.B26 (GND), J6.B29 (GND), J6.B32 (GND), J6.B35 (GND), J6.B36 (GND), J6.B39 (GND), J6.B40 (GND), J6.B43 (GND), J6.B44 (GND), J6.B47 (GND), J6.B49 (GND), J500.A1 (GND), J500.A12 (GND), J500.B1 (GND), J500.B12 (GND), J610.4 (GND), J610.7 (GND), J610.10 (GND), J610.13 (GND), J610.16 (GND), J610.SH (SHELL), J611.4 (GND), J611.7 (GND), J611.10 (GND), J611.13 (GND), J611.16 (GND), J611.SH (SHELL), J612.4 (GND), J612.7 (GND), J612.10 (GND), J612.13 (GND), J612.16 (GND), J612.SH (SHELL), J613.4 (GND), J613.7 (GND), J613.10 (GND), J613.13 (GND), J613.16 (GND), J613.SH (SHELL), J614.4 (GND), J614.7 (GND), J614.10 (GND), J614.13 (GND), J614.16 (GND), J614.SH (SHELL), J615.4 (GND), J615.7 (GND), J615.10 (GND), J615.13 (GND), J615.16 (GND), J615.SH (SHELL), J616.4 (GND), J616.7 (GND), J616.10 (GND), J616.13 (GND), J616.16 (GND), J616.SH (SHELL), J617.4 (GND), J617.7 (GND), J617.10 (GND), J617.13 (GND), J617.16 (GND), J617.SH (SHELL), J900.27, J900.28, J901.28, J902.5, J902.6, J902.7, J902.8, J902.9, J902.10, J902.11, J902.12, J902.13, J902.14, J910.29, J911.1, J911.2, J911.3, J911.4, J911.5, J911.6, J911.7, J911.8, J911.9, J911.10, J911.11, J911.12, J911.13, J911.14, J911.15, J923.1, J925.1, J930.1 (GND), MC1.3 (DGND), MC1.29 (DGND), MC1.30 (DGND), MC1.59 (DGND), MC1.60 (DGND), MC1.77 (DGND), MC1.78 (DGND), MC2.5 (DGND), MC2.6 (DGND), MC2.7 (DGND), MC2.8 (DGND), MC2.33 (DGND), MC2.34 (DGND), MC2.67 (DGND), MC2.68 (DGND), MC2.73 (DGND), MC3.0 (DGND), Q1.1 (S1), Q1.4 (S2), R24.1, R32.1, R33.1, R500.1, R501.2, R502.2, R507.2, R600.2, R606.1, R608.1, R613.2, R616.2, R701.1, R702.1, R711.1, R712.1, R713.1, R714.1, R715.1, R716.1, R717.1, R718.1, SW601.1 (ENABLE_GND), SW601.7 (OFF_GND), TP709.1, TP721.1, TP725.1, TP728.1, TP731.1, TP733.1, TP735.1, TP737.1, TP739.1, U2.1 (GND), U4.2 (GND), U4.5 (DIR), U5.2 (GND), U6.1 (GND), U501.4 (AGND), U501.9 (AGND), U501.10 (GND), U501.11 (GND), U501.22 (GND), U501.23 (GND), U501.35 (GND), U501.36 (GND), U501.41 (AGND), U501.42 (TEST), U501.47 (GND), U501.48 (GND), U501.PAD, U505.5 (VSS), U602.7 (GND), U603.2 (GND), U605.2 (GND), U610.5 (GND), U611.5 (GND), U612.5 (GND), U613.5 (GND), U614.5 (GND), U615.5 (GND), U616.5 (GND), U617.5 (GND), U618.5 (GND), U700.6 (AGND), U700.11 (AGND), U700.17 (PGND), U700.18 (PGND), U700.19 (PGND), U700.20 (PGND), U701.2 (GND), U702.2 (GND), U703.2 (GND), U704.2 (GND), U705.2 (GND), U706.2 (GND), U707.2 (GND), U708.2 (GND), U801.3 (GND), U801.8 (GND), U802.3 (GND), U802.8 (GND), U803.3 (GND), U803.8 (GND), U804.3 (GND), U804.8 (GND), U805.3 (GND), U805.8 (GND), U806.3 (GND), U806.8 (GND), U807.3 (GND), U807.8 (GND), U808.3 (GND), U808.8 (GND), U809.3 (GND), U809.8 (GND), U810.3 (GND), U810.8 (GND), U811.3 (GND), U811.8 (GND), U812.3 (GND), U812.8 (GND), U813.3 (GND), U813.8 (GND), U814.3 (GND), U814.8 (GND), U815.3 (GND), U815.8 (GND), U816.3 (GND), U816.8 (GND), Y500.2 (CASE), Y500.4 (CASE)
DRIVE_ENABLE: R615.2, R616.1, TP727.1, U602.8 (OE), U605.1 (RESET_N)
FE_5V: C704.1, C705.1, C706.1, C707.1, C708.1, C711.1, C712.1, C713.1, C714.1, C715.1, C716.1, C717.1, C718.1, R700.2, R703.2, R721.2, R722.2, R723.2, R724.2, R725.2, R726.2, R727.2, R728.2, TP700.1, U700.5 (VLDOIN), U700.8 (VOUT1), U700.9 (VOUT2), U701.1 (IN), U702.1 (IN), U703.1 (IN), U704.1 (IN), U705.1 (IN), U706.1 (IN), U707.1 (IN), U708.1 (IN)
FTDI3V3: C505.1, C507.1, C508.1, C509.1, C510.1, C511.1, C512.1, C604.1, FB500.1, FB501.1, R503.1, R505.2, R506.1, R509.2, TP713.1, U501.12 (VCCIO), U501.24 (VCCIO), U501.39 (VCCD), U501.46 (VCCIO), U505.8 (VCC), U602.1 (VCCA_3V3)
GNDADC: MC2.77 (GNDADC), MC2.79 (VREFP)
HDMI1_JTAG_TCK: J610.17 (TCK), R640.2
HDMI1_JTAG_TDI: J610.15 (TDI), R641.2
HDMI1_JTAG_TDO: J610.18 (TDO), R643.2
HDMI1_JTAG_TMS: J610.2 (TMS), R642.2
HDMI1_VREF: J610.1 (VREF), U611.13 (NO2)
HDMI2_JTAG_TCK: J611.17 (TCK), R644.2
HDMI2_JTAG_TDI: J611.15 (TDI), R645.2
HDMI2_JTAG_TDO: J611.18 (TDO), R647.2
HDMI2_JTAG_TMS: J611.2 (TMS), R646.2
HDMI2_VREF: J611.1 (VREF), U612.13 (NO2)
HDMI3_JTAG_TCK: J612.17 (TCK), R648.2
HDMI3_JTAG_TDI: J612.15 (TDI), R649.2
HDMI3_JTAG_TDO: J612.18 (TDO), R651.2
HDMI3_JTAG_TMS: J612.2 (TMS), R650.2
HDMI3_VREF: J612.1 (VREF), U613.13 (NO2)
HDMI4_JTAG_TCK: J613.17 (TCK), R652.2
HDMI4_JTAG_TDI: J613.15 (TDI), R653.2
HDMI4_JTAG_TDO: J613.18 (TDO), R655.2
HDMI4_JTAG_TMS: J613.2 (TMS), R654.2
HDMI4_VREF: J613.1 (VREF), U614.13 (NO2)
HDMI5_JTAG_TCK: J614.17 (TCK), R656.2
HDMI5_JTAG_TDI: J614.15 (TDI), R657.2
HDMI5_JTAG_TDO: J614.18 (TDO), R659.2
HDMI5_JTAG_TMS: J614.2 (TMS), R658.2
HDMI5_VREF: J614.1 (VREF), U615.13 (NO2)
HDMI6_JTAG_TCK: J615.17 (TCK), R660.2
HDMI6_JTAG_TDI: J615.15 (TDI), R661.2
HDMI6_JTAG_TDO: J615.18 (TDO), R663.2
HDMI6_JTAG_TMS: J615.2 (TMS), R662.2
HDMI6_VREF: J615.1 (VREF), U616.13 (NO2)
HDMI7_JTAG_TCK: J616.17 (TCK), R664.2
HDMI7_JTAG_TDI: J616.15 (TDI), R665.2
HDMI7_JTAG_TDO: J616.18 (TDO), R667.2
HDMI7_JTAG_TMS: J616.2 (TMS), R666.2
HDMI7_VREF: J616.1 (VREF), U617.13 (NO2)
HDMI8_JTAG_TCK: J617.17 (TCK), R668.2
HDMI8_JTAG_TDI: J617.15 (TDI), R669.2
HDMI8_JTAG_TDO: J617.18 (TDO), R671.2
HDMI8_JTAG_TMS: J617.2 (TMS), R670.2
HDMI8_VREF: J617.1 (VREF), U618.13 (NO2)
HOST_TCK: TP726.1, U501.13 (ADBUS0_/_TCK_/_SK), U602.2 (A1_TCK)
HOST_TDI: U501.14 (ADBUS1_/_TDI_/_DO), U602.3 (A2_TDI)
HOST_TDO: R509.1, TP732.1, U501.15 (ADBUS2_/_TDO_/_DI), U602.5 (A4Y_TDO)
HOST_TMS: U501.16 (ADBUS3_/_TMS_/_CS), U602.4 (A3_TMS)
JTAG_TCK: MC2.76 (JTAG_TCK), U610.17 (NO4)
JTAG_TCK_1V8: R601.2, TP720.1, U610.9 (COM4), U611.9 (COM4), U612.9 (COM4), U613.9 (COM4), U614.9 (COM4), U615.9 (COM4), U616.9 (COM4), U617.9 (COM4), U618.9 (COM4)
JTAG_TDI: MC2.74 (JTAG_TDI), U610.16 (NO6)
JTAG_TDI_1V8: R602.2, TP723.1, U610.12 (COM6), U611.12 (COM6), U612.12 (COM6), U613.12 (COM6), U614.12 (COM6), U615.12 (COM6), U616.12 (COM6), U617.12 (COM6), U618.12 (COM6)
JTAG_TDO: MC2.71 (JTAG_TDO), U610.18 (NO5)
JTAG_TDO_1V8: TP724.1, U602.10 (B4_TDO), U610.10 (COM5), U611.10 (COM5), U612.10 (COM5), U613.10 (COM5), U614.10 (COM5), U615.10 (COM5), U616.10 (COM5), U617.10 (COM5), U618.10 (COM5)
JTAG_TMS: MC2.72 (JTAG_TMS), U610.15 (NO3)
JTAG_TMS_1V8: R603.2, TP722.1, U610.7 (COM3), U611.7 (COM3), U612.7 (COM3), U613.7 (COM3), U614.7 (COM3), U615.7 (COM3), U616.7 (COM3), U617.7 (COM3), U618.7 (COM3)
MASTER: R600.1, R614.1, SW601.6 (MASTER)
MGT_REFCLK1N_225_C: C8.2, MC3.19 (MGT_REFCLK1N_225_C)
MGT_REFCLK1P_225_C: C7.2, MC3.17 (MGT_REFCLK1P_225_C)
MGT_RXN0_224: C746.1, J610.5 (TX0_N), U801.2 (IO2), U801.9 (IO2_FT)
MGT_RXN0_225: J6.B28 (PETn3), MC3.23 (MGT_RXN0_225)
MGT_RXN0_226: C754.1, J614.5 (TX0_N), U805.2 (IO2), U805.9 (IO2_FT)
MGT_RXN1_224: C748.1, J611.5 (TX0_N), U802.2 (IO2), U802.9 (IO2_FT)
MGT_RXN1_225: J6.B24 (PETn2), MC3.27 (MGT_RXN1_225)
MGT_RXN1_226: C756.1, J615.5 (TX0_N), U806.2 (IO2), U806.9 (IO2_FT)
MGT_RXN2_224: C750.1, J612.5 (TX0_N), U803.2 (IO2), U803.9 (IO2_FT)
MGT_RXN2_225: J6.B20 (PETn1), MC3.31 (MGT_RXN2_225)
MGT_RXN2_226: C758.1, J616.5 (TX0_N), U807.2 (IO2), U807.9 (IO2_FT)
MGT_RXN3_224: C752.1, J613.5 (TX0_N), U804.2 (IO2), U804.9 (IO2_FT)
MGT_RXN3_225: J6.B15 (PETn0), MC3.35 (MGT_RXN3_225)
MGT_RXN3_226: C760.1, J617.5 (TX0_N), U808.2 (IO2), U808.9 (IO2_FT)
MGT_RXP0_224: C745.1, J610.3 (TX0_P), U801.1 (IO1), U801.10 (IO1_FT)
MGT_RXP0_225: J6.B27 (PETp3), MC3.21 (MGT_RXP0_225)
MGT_RXP0_226: C753.1, J614.3 (TX0_P), U805.1 (IO1), U805.10 (IO1_FT)
MGT_RXP1_224: C747.1, J611.3 (TX0_P), U802.1 (IO1), U802.10 (IO1_FT)
MGT_RXP1_225: J6.B23 (PETp2), MC3.25 (MGT_RXP1_225)
MGT_RXP1_226: C755.1, J615.3 (TX0_P), U806.1 (IO1), U806.10 (IO1_FT)
MGT_RXP2_224: C749.1, J612.3 (TX0_P), U803.1 (IO1), U803.10 (IO1_FT)
MGT_RXP2_225: J6.B19 (PETp1), MC3.29 (MGT_RXP2_225)
MGT_RXP2_226: C757.1, J616.3 (TX0_P), U807.1 (IO1), U807.10 (IO1_FT)
MGT_RXP3_224: C751.1, J613.3 (TX0_P), U804.1 (IO1), U804.10 (IO1_FT)
MGT_RXP3_225: J6.B14 (PETp0), MC3.33 (MGT_RXP3_225)
MGT_RXP3_226: C759.1, J617.3 (TX0_P), U808.1 (IO1), U808.10 (IO1_FT)
MGT_TXN0_225: C20.2, MC3.24 (MGT_TXN0_225)
MGT_TXN1_225: C18.2, MC3.28 (MGT_TXN1_225)
MGT_TXN2_225: C16.2, MC3.32 (MGT_TXN2_225)
MGT_TXN3_225: C14.2, MC3.36 (MGT_TXN3_225)
MGT_TXP0_225: C19.2, MC3.22 (MGT_TXP0_225)
MGT_TXP1_225: C17.2, MC3.26 (MGT_TXP1_225)
MGT_TXP2_225: C15.2, MC3.30 (MGT_TXP2_225)
MGT_TXP3_225: C13.2, MC3.34 (MGT_TXP3_225)
unnamed: C502.1, FB503.2, J500.M1 (SHELL), J500.M2 (SHELL), J500.M3 (SHELL), J500.M4 (SHELL)
unnamed: D701.2 (A), R721.1
unnamed: D701.1 (K), U701.4 (FAULT)
unnamed: D702.2 (A), R722.1
unnamed: D702.1 (K), U702.4 (FAULT)
unnamed: D703.2 (A), R723.1
unnamed: D703.1 (K), U703.4 (FAULT)
unnamed: D704.2 (A), R724.1
unnamed: D704.1 (K), U704.4 (FAULT)
unnamed: D705.2 (A), R725.1
unnamed: D705.1 (K), U705.4 (FAULT)
unnamed: D706.2 (A), R726.1
unnamed: D706.1 (K), U706.4 (FAULT)
unnamed: D707.2 (A), R727.1
unnamed: D707.1 (K), U707.4 (FAULT)
unnamed: D708.2 (A), R728.1
unnamed: D708.1 (K), U708.4 (FAULT)
unnamed: J6.B31 (PRSNT2#), R28.1
unnamed: J500.A5 (CC1), R500.2
unnamed: J500.B5 (CC2), R501.1
unnamed: C746.2, MC3.3 (MGT_RXN0_224)
unnamed: C754.2, MC3.43 (MGT_RXN0_226)
unnamed: C748.2, MC3.7 (MGT_RXN1_224)
unnamed: C756.2, MC3.47 (MGT_RXN1_226)
unnamed: C750.2, MC3.11 (MGT_RXN2_224)
unnamed: C758.2, MC3.51 (MGT_RXN2_226)
unnamed: C752.2, MC3.15 (MGT_RXN3_224)
unnamed: C760.2, MC3.55 (MGT_RXN3_226)
unnamed: C745.2, MC3.1 (MGT_RXP0_224)
unnamed: C753.2, MC3.41 (MGT_RXP0_226)
unnamed: C747.2, MC3.5 (MGT_RXP1_224)
unnamed: C755.2, MC3.45 (MGT_RXP1_226)
unnamed: C749.2, MC3.9 (MGT_RXP2_224)
unnamed: C757.2, MC3.49 (MGT_RXP2_226)
unnamed: C751.2, MC3.13 (MGT_RXP3_224)
unnamed: C759.2, MC3.53 (MGT_RXP3_226)
unnamed: Q1.5 (G2), Q1.6 (D1), R30.1
unnamed: R18.1, TP21.1, U5.4 (~FAULT)
unnamed: C10.2, R13.1, U2.7 (VREF2), U2.8 (EN)
unnamed: C11.2, R2.1, U4.1 (Vcca)
unnamed: R24.2, U5.5 (ILIM)
unnamed: C28.2, R23.1, U6.7 (VREF2), U6.8 (EN)
unnamed: C503.1, U501.1 (OSCI), Y500.1 (OSC1)
unnamed: C504.1, U501.2 (OSCO), Y500.3 (OSC2)
unnamed: R507.1, U501.5 (REF)
unnamed: C518.2, U501.37 (VCCA)
unnamed: C517.2, U501.38 (VCORE)
unnamed: C519.1, R506.2, U501.34 (~RESET)
unnamed: R504.2, R505.1, U505.4 (DO)
unnamed: R601.1, U602.13 (B1Y_TCK)
unnamed: R602.1, U602.12 (B2Y_TDI)
unnamed: R603.1, U602.11 (B3Y_TMS)
unnamed: R605.2, R606.2, U603.3 (INA+)
unnamed: R607.2, R608.2, U603.4 (INB-)
unnamed: R629.1, U610.13 (NO2)
unnamed: R642.1, U611.15 (NO3)
unnamed: R640.1, U611.17 (NO4)
unnamed: R643.1, U611.18 (NO5)
unnamed: R641.1, U611.16 (NO6)
unnamed: R646.1, U612.15 (NO3)
unnamed: R644.1, U612.17 (NO4)
unnamed: R647.1, U612.18 (NO5)
unnamed: R645.1, U612.16 (NO6)
unnamed: R650.1, U613.15 (NO3)
unnamed: R648.1, U613.17 (NO4)
unnamed: R651.1, U613.18 (NO5)
unnamed: R649.1, U613.16 (NO6)
unnamed: R654.1, U614.15 (NO3)
unnamed: R652.1, U614.17 (NO4)
unnamed: R655.1, U614.18 (NO5)
unnamed: R653.1, U614.16 (NO6)
unnamed: R658.1, U615.15 (NO3)
unnamed: R656.1, U615.17 (NO4)
unnamed: R659.1, U615.18 (NO5)
unnamed: R657.1, U615.16 (NO6)
unnamed: R662.1, U616.15 (NO3)
unnamed: R660.1, U616.17 (NO4)
unnamed: R663.1, U616.18 (NO5)
unnamed: R661.1, U616.16 (NO6)
unnamed: R666.1, U617.15 (NO3)
unnamed: R664.1, U617.17 (NO4)
unnamed: R667.1, U617.18 (NO5)
unnamed: R665.1, U617.16 (NO6)
unnamed: R670.1, U618.15 (NO3)
unnamed: R668.1, U618.17 (NO4)
unnamed: R671.1, U618.18 (NO5)
unnamed: R669.1, U618.16 (NO6)
unnamed: U700.3 (CBOOT), U700.4 (RBOOT)
unnamed: C708.2, R700.1, R701.2, U700.10 (FB)
unnamed: R702.2, U700.12 (RT)
unnamed: R711.2, U701.5 (ILIM)
unnamed: R712.2, U702.5 (ILIM)
unnamed: R713.2, U703.5 (ILIM)
unnamed: R714.2, U704.5 (ILIM)
unnamed: R715.2, U705.5 (ILIM)
unnamed: R716.2, U706.5 (ILIM)
unnamed: R717.2, U707.5 (ILIM)
unnamed: R718.2, U708.5 (ILIM)
unnamed: U809.1 (IO1), U809.10 (IO1_FT)
unnamed: U809.2 (IO2), U809.9 (IO2_FT)
unnamed: U810.1 (IO1), U810.10 (IO1_FT)
unnamed: U810.2 (IO2), U810.9 (IO2_FT)
unnamed: U815.1 (IO1), U815.10 (IO1_FT)
unnamed: U815.2 (IO2), U815.9 (IO2_FT)
unnamed: U816.1 (IO1), U816.10 (IO1_FT)
unnamed: U816.2 (IO2), U816.9 (IO2_FT)
PORT1_5V: C721.1, J610.19 (PORT_5V), TP701.1, U701.6 (OUT)
PORT2_5V: C722.1, J611.19 (PORT_5V), TP702.1, U702.6 (OUT)
PORT3_5V: C723.1, J612.19 (PORT_5V), TP703.1, U703.6 (OUT)
PORT4_5V: C724.1, J613.19 (PORT_5V), TP704.1, U704.6 (OUT)
PORT5_5V: C725.1, J614.19 (PORT_5V), TP705.1, U705.6 (OUT)
PORT6_5V: C726.1, J615.19 (PORT_5V), TP706.1, U706.6 (OUT)
PORT7_5V: C727.1, J616.19 (PORT_5V), TP707.1, U707.6 (OUT)
PORT8_5V: C728.1, J617.19 (PORT_5V), TP708.1, U708.6 (OUT)
PORT_ENABLE: R703.1, TP736.1, U700.13 (PG), U701.3 (EN), U702.3 (EN), U703.3 (EN), U704.3 (EN), U705.3 (EN), U706.3 (EN), U707.3 (EN), U708.3 (EN)
ROTARY_COMMON: SW600.3, SW601.2 (ROTARY_COM)
SEL_0: R620.2, SW600.1 (POS1), U610.20 (DISABLE_HIGH)
SEL_1: R621.2, SW600.2 (POS2), U611.20 (DISABLE_HIGH)
SEL_2: R622.2, SW600.4 (POS3), U612.20 (DISABLE_HIGH)
SEL_3: R623.2, SW600.5 (POS4), U613.20 (DISABLE_HIGH)
SEL_4: R624.2, SW600.6 (POS5), U614.20 (DISABLE_HIGH)
SEL_5: R625.2, SW600.7 (POS6), U615.20 (DISABLE_HIGH)
SEL_6: R626.2, SW600.8 (POS7), U616.20 (DISABLE_HIGH)
SEL_7: R627.2, SW600.9 (POS8), U617.20 (DISABLE_HIGH)
SEL_8: R628.2, SW600.10 (POS9), U618.20 (DISABLE_HIGH)
USB5V: C506.2, D500.5 (VBUS), FB502.1, J500.A4 (VBUS), J500.A9 (VBUS), J500.B4 (VBUS), J500.B9 (VBUS), TP734.1
USB_DM_CONN: D500.4 (I/O2), J500.A7 (DN1), J500.B7 (DN2)
USB_DP_CONN: D500.6 (I/O1), J500.A6 (DP1), J500.B6 (DP2)
USB_D_N: D500.3 (I/O2), U501.6 (DM)
USB_D_P: D500.1 (I/O1), U501.7 (DP)
VBATT: J910.27, MC1.79 (VBATT)
VIO1: C9.2, C27.2, J910.30, J921.1, MC1.1 (VIO1), Q1.2 (G1), R14.2, R15.2, R25.2, R33.2, U2.2 (VREF1), U6.2 (VREF1)
VIO2: J910.17, J928.1, MC1.80 (VIO2)
VIO3: J901.15, J927.1, MC2.69 (VIO3)
VREF1: J910.8, MC1.4 (VREF1)
VREF_SELECTED: C608.1, R605.1, R607.1, R613.1, TP729.1, U610.6 (COM2), U611.6 (COM2), U612.6 (COM2), U613.6 (COM2), U614.6 (COM2), U615.6 (COM2), U616.6 (COM2), U617.6 (COM2), U618.6 (COM2)
WINDOW_GATE: R614.2, TP730.1, U603.1 (OUTA), U603.6 (OUTB), U605.3 (MR_N)

Notes on the sheet:
Function: HDMI6 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
Function: HDMI5 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
Function: HDMI 5 carries recording (3/5), 32 MHz clock (6/8), command with SYNC (9/11), JTAG, sense and 5 V; 12/14 separate SYNC (LVDS). U805/U813 shunt data-line ESD; shell is bonded to DGND.
Function: HDMI1 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J611: 3/5 MGT_RXP1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
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J616: 3/5 MGT_RXP2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
Function: HDMI 3 carries recording (3/5), 32 MHz clock (6/8), command with SYNC (9/11), JTAG, sense and 5 V; 12/14 separate SYNC (LVDS). U803/U811 shunt data-line ESD; shell is bonded to DGND.
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J617: 3/5 MGT_RXP3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
USB-C JTAG PROGRAMMER, SELECTION AND FRONTEND PORTS
Function: U700 converts +VDCIN to FE_5V (5.02 V nominal, 6 A module rating). PG and R703 enable all eight ports once the central rail is in regulation. Source / changes: TI TPSM63606 SLVSGB4B Rev. B, Fig. 9-1 and Table 8-1, https://www.ti.com/lit/ds/symlink/tpsm63606.pdf . Codex adapted prior V14 U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
Source / changes: Codex circuit using TI TS3A27518E Rev F Fig.5-2, Table 8-1: https://www.ti.com/lit/ds/symlink/ts3a27518e.pdf IN1/IN2 high select NO; active-low EN from rotary; 10k pullup. Channels (Howard 1 Nov 2026, for straight PCB routing): TCK=4, TDI=6, TMS=3, TDO=5, VREF=2; channel 1 unused.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
USB TO JTAG PROGRAMMER
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J612: 3/5 MGT_RXP2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
XEM8310 MODULE MOUNTING HOLES
Function: HDMI 7 carries recording (3/5), 32 MHz clock (6/8), command with SYNC (9/11), JTAG, sense and 5 V; 12/14 not connected (no SYNC). U807/U815 shunt data-line ESD; shell is bonded to DGND.
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J610: 3/5 MGT_RXP0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
Function: U701-U708 individually switch FE_5V to J610-J617 pin 19; red LEDs indicate each switch FAULT. TP701-TP708 access the outputs. All ports start together; no staggering. Source / changes: TI TPS2553 SLVS841G Rev. G, pins / sections 8-9 and Table 9-2: https://www.ti.com/lit/ds/symlink/tps2553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
Function: HDMI2 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J613: 3/5 MGT_RXP3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
Function: HDMI8 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
FRONTEND 5 V POWER | CUSTOM MICRO-HDMI PORTS - NOT STANDARD HDMI
Function: HDMI 8 carries recording (3/5), 32 MHz clock (6/8), command with SYNC (9/11), JTAG, sense and 5 V; 12/14 not connected (no SYNC). U808/U816 shunt data-line ESD; shell is bonded to DGND.
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J614: 3/5 MGT_RXP0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
Function: HDMI 6 carries recording (3/5), 32 MHz clock (6/8), command with SYNC (9/11), JTAG, sense and 5 V; 12/14 separate SYNC (LVDS). U806/U814 shunt data-line ESD; shell is bonded to DGND.
Function: HDMI4 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
Function: HDMI 4 carries recording (3/5), 32 MHz clock (6/8), command with SYNC (9/11), JTAG, sense and 5 V; 12/14 separate SYNC (LVDS). U804/U812 shunt data-line ESD; shell is bonded to DGND.
Function: HDMI3 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
Function: HDMI 1 carries recording (3/5), 32 MHz clock (6/8), command with SYNC (9/11), JTAG, sense and 5 V; 12/14 not connected (no SYNC). U801/U809 shunt data-line ESD; shell is bonded to DGND.
Function: HDMI7 selects shared JTAG and VREF. 100R series parts alone do not provide 5 V protection.
HDMI EXTENSION BOARD - XEM8310 CONNECTIONS, POWER AND MOUNTING
Source / changes: Codex custom interface; Molex 467651001 SD-46765-001 sheets 1-2: https://www.molex.com/content/dam/molex/molex-dot-com/products/automated/en-us/salesdrawingpdf/467/46765/467651001_sd.pdf?inline= XEM connector pin list: https://pins.opalkelly.com/pin_list/XEM8310 J615: 3/5 MGT_RXP1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
Power Jack
12 V nominal, center positive
Function: HDMI 2 carries recording (3/5), 32 MHz clock (6/8), command with SYNC (9/11), JTAG, sense and 5 V; 12/14 not connected (no SYNC). U802/U810 shunt data-line ESD; shell is bonded to DGND.
1. Function: ties VREFP (MC2.79) to GNDADC (MC2.77), which selects the FPGA internal ADC reference. 2. Source / changes: Opal Kelly XEM8310 Hardware Design Guide, Selecting the ADC Reference Voltage, revision not stated: https://docs.opalkelly.com/xem8310/hardware-design-guide/ BRK8310-A01 SYSMON H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
PCIe x4 — BRK8310 reference circuit
Function: Connects PCIe x4 data and 100 MHz reference clock, with reset, SMBus and WAKE#. Host slot 12 V is isolated from the board 12 V input.
Source / changes: Opal Kelly BRK8310-A01 schematic, p. 2, 2022-05-19: https://pins.opalkelly.com/downloads/442/download?category_id=3 Adapted from x8 to x4: fit R28 = 0 ohm; omit R29 and unused lanes 4–7 and C21–C26/C29–C30. R2/R7 and R9–R11 retained. Unused options R1/R8, R16/R17 and R27 are omitt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
Function: XEM8310 connectors provide the board power, FPGA I/O, JTAG and GT connections; J4 is the 12 V input; the module is held by its connectors and two M3 standoffs (holes MH2/MH3 on the board, restored in V36; MH1/MH4 are routed over).
Source / changes: Opal Kelly BRK8310-A01 p.1 (2022-05-19): https://pins.opalkelly.com/downloads/442/download?category_id=3 ; Codex assigned the custom HDMI and x4 nets. VIO1 target is 1.8 V; program and verify it. V24: J4 changed from CUI PJ-102AH (5 A) to Same Sky PJ-063AH (8 A, 24 V, same 2.0 mm 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
